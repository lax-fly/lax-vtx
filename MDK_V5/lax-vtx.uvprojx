# Keil uVision project lax-vtx.uvprojx, settings and files
target lax-vtx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F421G8U7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.1.2
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: lax-vtx +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F421G8U7,USE_STDPERIPH_DRIVER,AT_START_F421_V1,USE_PA_RFPA5542,USE_RTC6705,LED_INDICATION_OF_VTX_MODE=1
  c include: ..\src\driver\msp\cm4;..\src\utilities
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group vtx
    ../src/vtx/: configuration.cpp modeIndicator.cpp smartAudio.cpp mspVtx.cpp tramp.cpp errorCodes.cpp main.cpp protocol.cpp table.cpp
  group driver/bsp
    ../src/driver/bsp/: button.cpp led.cpp serial.cpp printf.cpp disk.cpp dev.cpp sensor.cpp radio.cpp timer.cpp
  group driver/chip
    ../src/driver/chip/: rfpa5542.cpp rtc6705.cpp chipset.cpp
  group driver/msp
    ../src/driver/msp/: adc.cpp clock.cpp crc.cpp flash.cpp gpio.cpp pwm.cpp usart.cpp
  group driver/msp/at32f421
    ../src/driver/msp/at32f421/: at32f421_adc.c at32f421_cmp.c at32f421_crc.c at32f421_crm.c at32f421_debug.c at32f421_dma.c at32f421_ertc.c at32f421_exint.c at32f421_flash.c at32f421_gpio.c at32f421_i2c.c at32f421_misc.c at32f421_pwc.c at32f421_scfg.c at32f421_spi.c at32f421_tmr.c at32f421_usart.c at32f421_wdt.c at32f421_wwdt.c system_at32f421.c
    ../startup/mdk/: startup_at32f421.s
